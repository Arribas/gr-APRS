options:
  parameters:
    author: 'Handiko '
    category: APRS
    description: www.github.com/handiko/gr-APRS
    generate_options: hb
    id: APRS_Rx
    output_language: python
    title: APRS Rx
  states: {}

blocks:
- name: AFSK_Demod_0
  id: AFSK_Demod
  parameters:
    baud: baud
    fsk_hi_tone: space
    fsk_lo_tone: mark
    in_sps: int(samp_rate/baud)
    out_sps: '2'
  states: {}
- name: baud
  id: parameter
  parameters:
    label: Baudrate
    type: intx
    value: '1200'
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gmu
    gain_omega: 0.25*gmu*gmu
    mu: mu
    omega: 2*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '32'
  states: {}
- name: gmu
  id: parameter
  parameters:
    label: Gain Mu
    type: eng_float
    value: '0.175'
  states: {}
- name: mark
  id: parameter
  parameters:
    label: Mark Freq (Hz)
    type: eng_float
    value: '1200'
  states: {}
- name: mu
  id: parameter
  parameters:
    label: Mu
    type: eng_float
    value: '0.5'
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: HDLC
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: Clock Sync
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_2_0
  id: pad_sink
  parameters:
    label: Demod
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: afsk in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate (Hz)
    type: eng_float
    value: 24e3
  states: {}
- name: space
  id: parameter
  parameters:
    label: Space Freq (Hz)
    type: eng_float
    value: '2400'
  states: {}

connections:
- [AFSK_Demod_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [AFSK_Demod_0, '0', pad_sink_2_0, '0']
- [blocks_and_const_xx_0, '0', digital_hdlc_deframer_bp_0, '0']
- [blocks_not_xx_0, '0', blocks_and_const_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', pad_sink_2, '0']
- [digital_diff_decoder_bb_0, '0', blocks_not_xx_0, '0']
- [digital_hdlc_deframer_bp_0, out, pad_sink_1, in]
- [pad_source_0, '0', AFSK_Demod_0, '0']

metadata:
  file_format: 1
