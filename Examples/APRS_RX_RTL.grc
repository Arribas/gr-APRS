options:
  parameters:
    author: Handiko
    description: www.github.com/handiko/gr-APRS
    generate_options: qt_gui
    id: APRS_RX_RTL
    output_language: python
    title: APRS - With RTL-SDR dongle
  states: {}

blocks:
- name: afgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: AF Gain (dB)
    min_len: '100'
    orient: Qt.Horizontal
    start: '-20'
    step: '0.1'
    stop: '-1'
    value: '-7'
  states: {}
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: bb_rate
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: ch_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: dev_ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '5000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 144.800e6 - samp_rate/4
  states: {}
- name: gmu
  id: variable
  parameters:
    value: '0.175'
  states: {}
- name: mark
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: RF Gain (dB)
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '49'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: space
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: APRS_Rx_0
  id: APRS_Rx
  parameters:
    baud: baud
    gmu: gmu
    mark: mark
    mu: mu
    samp_rate: ch_rate
    space: space
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: int(samp_rate)
    tau: '75e-6'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: ch_rate/(2*math.pi*12e3/8.0)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (2*math.pi*deviation)/ch_rate
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-math.pi/2'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import os, pty
      import struct

      import pmt
      import numpy as np
      from gnuradio import gr

      import packet


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Converts an array of bytes into a AX25Packet object.

          Connect to the "HDLC Deframer", or a block which emits a PMT tuple of
          (None, bytearray)
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                                     name="HDLC to AX.25",
                                     in_sig=None,
                                     out_sig=None)
              self.message_port_register_in(pmt.intern('hdlc in'))
              self.message_port_register_out(pmt.intern('ax25 out'))
              self.set_msg_handler(pmt.intern('hdlc in'), self.handle_msg)

          def handle_msg(self, msg_pmt):
              msg_pmt = pmt.pmt_to_python.pmt_to_python(msg_pmt)

              msg = bytearray(msg_pmt[1])

              try:
                  pkt = packet.from_bytes(msg)
                  self.message_port_pub(pmt.intern('ax25 out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(np.array([ord(c) for c in (packet.dump(pkt) + '\n')], np.uint8))))
                      
              except ValueError as e:
                  print(e)

          def stop(self):
              gr.sync_block.stop(self)
              
          def work(self, input_items, output_items):
              in0 = input_items[0]
              # <+signal processing here+>
              return len(input_items[0])
  states: {}
- name: fft_filter_xxx_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.band_pass(1,ch_rate,400,5e3,400,firdes.WIN_BLACKMAN)
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: dev_ppm
    freq0: freq
    gain0: rfgain
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pfb_decimator_ccf_0
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: '0'
    decim: int(samp_rate/bb_rate)
    taps: ()
  states: {}
- name: pfb_decimator_ccf_1
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: '0'
    decim: int(samp_rate/ch_rate)
    taps: ()
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.8'
    average: '0.2'
    bw: 192e3
    fc: 144.39e6
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,1,2
    legend: 'False'
    name: RF Spectrum
    showports: 'True'
    type: complex
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.8'
    average: '0.2'
    bw: 8e3
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 1,2,2,1
    legend: 'False'
    name: AF Spectrum
    showports: 'True'
    type: float
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '20'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: ''
    legend: 'False'
    name: Clock Recovery
    size: '256'
    srate: '1200'
    type: float
    width1: '2'
    ymax: '2.1'
    ymin: '-2.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 192e3
    color1: '6'
    fc: '0'
    fftsize: int(4096/2)
    gui_hint: 0,2,1,1
    int_max: '-20'
    int_min: '-105'
    legend: 'False'
    name: RF Spectrum
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(ch_rate)
    interp: '8000'
    taps: ()
    type: fff
  states: {state: disabled}

connections:
- [APRS_Rx_0, '0', qtgui_time_sink_x_0, '0']
- [APRS_Rx_0, HDLC, blocks_message_debug_0, print_pdu]
- [APRS_Rx_0, HDLC, epy_block_0_0, hdlc in]
- [analog_nbfm_rx_0, '0', audio_sink_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', audio_sink_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', fft_filter_xxx_1, '0']
- [analog_quadrature_demod_cf_0_0, '0', fft_filter_xxx_1, '0']
- [blocks_rotator_cc_0, '0', pfb_decimator_ccf_0, '0']
- [blocks_rotator_cc_0, '0', pfb_decimator_ccf_1, '0']
- [epy_block_0_0, ax25 out, blocks_socket_pdu_0, pdus]
- [fft_filter_xxx_1, '0', APRS_Rx_0, '0']
- [fft_filter_xxx_1, '0', audio_sink_0, '0']
- [fft_filter_xxx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [fft_filter_xxx_1, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_rotator_cc_0, '0']
- [pfb_decimator_ccf_0, '0', qtgui_freq_sink_x_0, '0']
- [pfb_decimator_ccf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pfb_decimator_ccf_1, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
