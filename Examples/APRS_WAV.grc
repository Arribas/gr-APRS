options:
  parameters:
    author: Handiko
    description: www.github.com/handiko/gr-APRS
    generate_options: qt_gui
    id: APRS_WAV
    output_language: python
    title: APRS - WAV
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: gmu
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: mark
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 24e3
  states: {}
- name: space
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: APRS_Rx_0
  id: APRS_Rx
  parameters:
    baud: baud
    gmu: gmu
    mark: mark
    mu: mu
    samp_rate: samp_rate
    space: space
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate)
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      File : gr-APRS/WAV/aprs.wav
      sample rate : 24 kHz
      bit depth : 16 bits
    file: /home/javier/sdr/gr-APRS/WAV/aprs.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import os, pty
      import struct

      import pmt
      import numpy as np
      from gnuradio import gr

      import packet


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Converts an array of bytes into a AX25Packet object.

          Connect to the "HDLC Deframer", or a block which emits a PMT tuple of
          (None, bytearray)
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                                     name="HDLC to AX.25",
                                     in_sig=None,
                                     out_sig=None)
              self.message_port_register_in(pmt.intern('hdlc in'))
              self.message_port_register_out(pmt.intern('ax25 out'))
              self.set_msg_handler(pmt.intern('hdlc in'), self.handle_msg)

          def handle_msg(self, msg_pmt):
              msg_pmt = pmt.pmt_to_python.pmt_to_python(msg_pmt)

              msg = bytearray(msg_pmt[1])

              try:
                  pkt = packet.from_bytes(msg)
                  self.message_port_pub(pmt.intern('ax25 out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(np.array([ord(c) for c in (packet.dump(pkt) + '\n')], np.uint8))))
                      
              except ValueError as e:
                  print(e)

          def stop(self):
              gr.sync_block.stop(self)
              
          def work(self, input_items, output_items):
              in0 = input_items[0]
              # <+signal processing here+>
              return len(input_items[0])
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.band_pass(1,samp_rate,1e3,2.6e3,100,firdes.WIN_BLACKMAN)
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tab@0:1,0,1,1
    label2: ''
    legend: 'False'
    name: Input Spectrum
    nconnections: '2'
    showports: 'True'
    type: float
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@0:0,0,1,1
    label1: ''
    legend: 'False'
    name: Input Waveform
    size: '1024'
    srate: samp_rate
    type: float
    width1: '2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@1:0,0,1,1
    label1: ''
    legend: 'False'
    name: Demodulator Output
    size: '512'
    srate: baud*2
    type: float
    width1: '2'
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@1:1,0,1,1
    label1: ''
    legend: 'False'
    name: Clock Sync Output
    size: '256'
    srate: baud
    type: float
    width1: '2'
    ymax: '5'
    ymin: '-5'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Input Signal
    label1: Demodulator Output
    num_tabs: '2'
  states: {}

connections:
- [APRS_Rx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [APRS_Rx_0, '1', qtgui_time_sink_x_0_0, '0']
- [APRS_Rx_0, HDLC, blocks_message_debug_1, print_pdu]
- [APRS_Rx_0, HDLC, epy_block_0, hdlc in]
- [blocks_wavfile_source_0, '0', fft_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0, '1']
- [epy_block_0, ax25 out, blocks_socket_pdu_0, pdus]
- [fft_filter_xxx_0, '0', APRS_Rx_0, '0']
- [fft_filter_xxx_0, '0', audio_sink_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
